Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2024-11-05T15:32:48
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcDistributionPort (4)
Description: Flow; FlowDirection: SOURCEANDSINK
Name | Group
2 x Port_720533 | Sanitary 2
2 x Port_720556 | Sanitary 1

# IfcFlowSegment: Flex Pipe Round:NBS_DeltaMembraneSystemsLtd_PolyethylenePEStructuredWallPerforatedBelow-groundDrainagePipesAndFittings_DeltaAquaduct (2)
In: Level 0
Type - PredefinedType: FLEXIBLESEGMENT
Type - IFC - IfcExportAs: IfcPipeSegmentType; IfcExportType: FLEXIBLESEGMENT
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_65_52_07_72:Polyethylene (PE) structured wall perforated below-ground drainage pipes and fittings; Color: n/a; Finish: n/a; Material: High density polyethylene (HDPE); Shape: n/a; Size: n/a; WarrantyDescription: n/a; CodePerformance: n/a; Constituents: n/a; Description: A range of corrugated perforated pressure relief drain pipes.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@deltamembranes.com; ModelNumber: n/a; ModelReference: Delta Aquaduct; Name: PolyethylenePEStructuredWallPerforatedBelow-groundDrainagePipesAndFittings_DeltaAquaduct_DeltaMembraneSystemsLtd; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_DeltaMembraneSystemsLtd_PolyethylenePEStructuredWallPerforatedBelow-groundDrainagePipesAndFittings_DeltaAquaduct; ManufacturerName: Delta Membrane Systems Ltd; ManufacturerURL: https://www.deltamembranes.com; ProductInformation: https://source.thenbs.com/product/-/f4fc2408-b62a-b866-feb1-95a4d929ad0d/38212a35-629e-4d27-ba7c-4e6a4d9ba95f; Uniclass2015Code: Pr_65_52_07_72; Uniclass2015Title: Polyethylene (PE) structured wall perforated below-ground drainage pipes and fittings; Uniclass2015Version: Products v1.35; Version: 6
Type - NBS_Data - ProductReference: Delta Aquaduct; ContainsRedListMaterials: No; CountryOfProductManufacture: United Kingdom; Material: High density polyethylene (HDPE); Recyclability: Yes; RecycledContent: 0; DiameterOptions: 60 mm,100 mm
Classification: Pr_65_52_07_72 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
Name (Flex Pipe Round:NBS_DeltaMembraneSystemsLtd_PolyethylenePEStructuredWallPerforatedBelow-groundDrainagePipesAndFittings_DeltaAquaduct:...) | Group
720533 | Sanitary 2
720556 | Sanitary 1

# IfcSystem: Sanitary (2)
COBie - Category: Piping Systems
Name
Sanitary 2
Sanitary 1
